/**

 *******************************************************************************

 * @file  Sysclk.c

 * @brief 鹼邁鬾T{歔鰁hVq毃R瀃皊

 * @note  fnx:SR"鰁煍恘O齹"孴"鹼邁鰁煍恘	愰b"

 *******************************************************************************

 */



#include "Sysclk.h"

#include "hc32_ll_utility.h"

#include "hc32_ll.h"



/*==============================================================================

 * Y`齉pe餢f - hQ钀ag鯪褘怣Q*g_(uf婮T

 *============================================================================*/



static void SysTick_NVIC_Config(void);

static int32_t SysTick_Clock_Enable(void);



#if (SYSTICK_ENABLE_PLL == 1UL)

static int32_t SysTick_PLL_Init(void);

#endif



#if (SYSTICK_ENABLE_XTAL == 1UL)

static int32_t SysTick_XTAL_Init(void);

#endif



#if (SYSTICK_ENABLE_XTAL32 == 1UL)

static int32_t SysTick_XTAL32_Init(void);

#endif



#if (SYSTICK_ENABLE_HRC == 1UL)

static int32_t SysTick_HRC_Init(void);

#endif



#if (SYSTICK_ENABLE_MRC == 1UL)

static int32_t SysTick_MRC_Init(void);

#endif



#if (SYSTICK_ENABLE_LRC == 1UL)

static int32_t SysTick_LRC_Init(void);

#endif



/*==============================================================================

 * 齉pe瀃皊

 *============================================================================*/



void SysTick_Handler(void)

{}



/**

 * @brief SysTick歔鰁hVR薡S(/UN鵞Yc鉙)

 * @param 鄀

 * @retval int32_t 0:b烺, -1:1Y%

 */

int32_t Systick_config(void)

{

    int32_t i32Ret;

    uint32_t u32Reload;

    stc_clock_freq_t stcClkFreq;

    

    /* 1. 銐d枡Q軴b */

    LL_PERIPH_WE(LL_PERIPH_ALL);

    

    /* 2. O齹T鰁煍恘(臢O齹, 
N	愰b) */

    i32Ret = SysTick_Clock_Enable();

    if (i32Ret != LL_OK) {

        return -1;

    }

    

    /* 3. M憂;`縹鰁煍R憳 */

    CLK_SetClockDiv(CLK_BUS_CLK_ALL, 

                    SYSTICK_HCLK_DIV | 

                    SYSTICK_EXCLK_DIV |

                    SYSTICK_PCLK0_DIV | 

                    SYSTICK_PCLK1_DIV |

                    SYSTICK_PCLK2_DIV | 

                    SYSTICK_PCLK3_DIV | 

                    SYSTICK_PCLK4_DIV);

    

    /* 4. I{卂PLL3z歔俌済O齹哊PLL	 */

#if (SYSTICK_ENABLE_PLL == 1UL)

    /* I{卂MPLL ready */

    while (SET != CLK_GetStableStatus(CLK_STB_FLAG_PLL)) {

        ;

    }

#endif

    

    /* 5. M憂SRAMI{卂hTg貧憳梺	 */

    SRAM_SetWaitCycle(SRAM_SRAMH, SRAM_WAIT_CYCLE0, SRAM_WAIT_CYCLE0);

    SRAM_SetWaitCycle((SRAM_SRAM12 | SRAM_SRAM3 | SRAM_SRAMR), SRAM_WAIT_CYCLE1, SRAM_WAIT_CYCLE1);

    

    /* 6. M憂FlashI{卂hTg200MHz梺5*NI{卂hTg	 */

    (void)EFM_SetWaitCycle(EFM_WAIT_CYCLE5);

    

    /* 7. M憂GPIO麐諷I{卂hTg */

    GPIO_SetReadWaitCycle(GPIO_RD_WAIT3);

    

    /* 8. Rbcq毃R齹汻貧憳梺	 */

    (void)PWC_HighSpeedToHighPerformance();

    

    /* 9. 緥n鹼邁鰁煍恘 */

    CLK_SetSysClockSrc(SYSTICK_SYSCLK_SRC);

    

    /* 10. 穬諷S_MR鹼邁鰁煍憳噑 */

    (void)CLK_GetClockFreq(&stcClkFreq);

    SystemCoreClock = stcClkFreq.u32SysclkFreq;

    

    /* 11. M憂X[ */

    EFM_CacheRamReset(ENABLE);

    EFM_CacheRamReset(DISABLE);

    EFM_CacheCmd(ENABLE);

    

    /* 12. M憂SysTick歔鰁hV */

    /* 鑜aSystemCoreClock = 200,000,000 Hz */

    /* u32Reload = 200,000,000 / 1000 - 1 = 199,999 */

    u32Reload = (SystemCoreClock / 1000UL) * SYSTICK_INT_INTERVAL_MS - 1UL;

    

    /* 纇錱蛻艌}<P/f&T厤菑24MOg'Y<P */

    if (u32Reload > SysTick_LOAD_RELOAD_Msk) {

        CLOCK_DEBUG("Error: Reload value %lu exceeds 24-bit max (0x%lX)", 

                    u32Reload, SysTick_LOAD_RELOAD_Msk);

        return -1;

    }

    

    CLOCK_DEBUG("SysTick reload value: %lu (expected 199999 for 200MHz)", u32Reload);

    

    SysTick->LOAD = u32Reload;

    SysTick->VAL = 0UL;

    SysTick->CTRL = (SYSTICK_CLK_SRC << SysTick_CTRL_CLKSOURCE_Pos) |

                    SysTick_CTRL_TICKINT_Msk |

                    SysTick_CTRL_ENABLE_Msk;

    

    /* 13. M憂-N璭OHQ~NOOHQ~媣Q諲-N璭OHQ	 */

    SysTick_NVIC_Config();

    

    /* 14. 絜燫橯軴b */

    LL_PERIPH_WP(LL_PERIPH_EFM  | LL_PERIPH_SRAM);

    

    /* 15. SbpSM憂觺済 */

    Print_All_Clock_Freq();

    

    return 0;

}



/**

 * @brief 鰁煍恘O齹(闟O齹, 
N	愰b)

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

static int32_t SysTick_Clock_Enable(void)

{

    int32_t i32Ret = LL_OK;

    

    /* 1. O齹HRC */

    #if (SYSTICK_ENABLE_HRC == 1UL)

    i32Ret = SysTick_HRC_Init();

    if (i32Ret != LL_OK) return i32Ret;

    #endif

    

    /* 2. O齹MRC */

    #if (SYSTICK_ENABLE_MRC == 1UL)

    i32Ret = SysTick_MRC_Init();

    if (i32Ret != LL_OK) return i32Ret;

    #endif

    

    /* 3. O齹LRC */

    #if (SYSTICK_ENABLE_LRC == 1UL)

    i32Ret = SysTick_LRC_Init();

    if (i32Ret != LL_OK) return i32Ret;

    #endif

    

    /* 4. O齹XTAL */

    #if (SYSTICK_ENABLE_XTAL == 1UL)

    i32Ret = SysTick_XTAL_Init();

    if (i32Ret != LL_OK) return i32Ret;

    #endif

    

    /* 5. O齹XTAL32 */

    #if (SYSTICK_ENABLE_XTAL32 == 1UL)

    i32Ret = SysTick_XTAL32_Init();

    if (i32Ret != LL_OK) return i32Ret;

    #endif

    

    /* 6. O齹PLL */

    #if (SYSTICK_ENABLE_PLL == 1UL)

    i32Ret = SysTick_PLL_Init();

    if (i32Ret != LL_OK) return i32Ret;

    #endif

    

    return LL_OK;

}



/**

 * @brief PLLR薡S

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

#if (SYSTICK_ENABLE_PLL == 1UL)

static int32_t SysTick_PLL_Init(void)

{

    int32_t i32Ret;

    stc_clock_pll_init_t stcPLLInit;

    

    (void)CLK_PLLStructInit(&stcPLLInit);

    

    stcPLLInit.PLLCFGR = 0UL;

    stcPLLInit.PLLCFGR_f.PLLSRC = SYSTICK_PLL_SRC;

    stcPLLInit.PLLCFGR_f.PLLM = SYSTICK_PLL_M - 1UL;

    stcPLLInit.PLLCFGR_f.PLLN = SYSTICK_PLL_N - 1UL;

    stcPLLInit.PLLCFGR_f.PLLP = SYSTICK_PLL_P - 1UL;

    stcPLLInit.PLLCFGR_f.PLLQ = SYSTICK_PLL_Q - 1UL;

    stcPLLInit.PLLCFGR_f.PLLR = SYSTICK_PLL_R - 1UL;

    stcPLLInit.u8PLLState = CLK_PLL_ON;

    

    i32Ret = CLK_PLLInit(&stcPLLInit);

    return i32Ret;

}

#endif



/**

 * @brief Y钀vf/cR薡S

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

#if (SYSTICK_ENABLE_XTAL == 1UL)

static int32_t SysTick_XTAL_Init(void)

{

    stc_clock_xtal_init_t stcXtalInit;

    

    (void)CLK_XtalStructInit(&stcXtalInit);

    

    stcXtalInit.u8State = CLK_XTAL_ON;

    stcXtalInit.u8Mode = CLK_XTAL_MD_OSC;

    stcXtalInit.u8Drv = CLK_XTAL_DRV_ULOW;

    stcXtalInit.u8StableTime = CLK_XTAL_STB_2MS;

    

    return CLK_XtalInit(&stcXtalInit);

}

#endif



/**

 * @brief 32.768kHzY钀vf/cR薡S

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

#if (SYSTICK_ENABLE_XTAL32 == 1UL)

static int32_t SysTick_XTAL32_Init(void)

{

    stc_clock_xtal32_init_t stcXtal32Init;

    

    (void)CLK_Xtal32StructInit(&stcXtal32Init);

    

    stcXtal32Init.u8State = CLK_XTAL32_ON;

    stcXtal32Init.u8Drv = CLK_XTAL32_DRV_MID;

    stcXtal32Init.u8Filter = CLK_XTAL32_FILTER_ALL_MD;

    

    return CLK_Xtal32Init(&stcXtal32Init);

}

#endif



/**

 * @brief HRCR薡S

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

#if (SYSTICK_ENABLE_HRC == 1UL)

static int32_t SysTick_HRC_Init(void)

{

    return CLK_HrcCmd(ENABLE);

}

#endif



/**

 * @brief MRCR薡S

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

#if (SYSTICK_ENABLE_MRC == 1UL)

static int32_t SysTick_MRC_Init(void)

{

    return CLK_MrcCmd(ENABLE);

}

#endif



/**

 * @brief LRCR薡S

 * @param 鄀

 * @retval int32_t 0:b烺, vQ諲:1Y%

 */

#if (SYSTICK_ENABLE_LRC == 1UL)

static int32_t SysTick_LRC_Init(void)

{

    return CLK_LrcCmd(ENABLE);

}

#endif



/**

 * @brief SysTick-N璭OHQ~M憂

 * @param 鄀

 * @retval 鄀

 */

static void SysTick_NVIC_Config(void)

{

    NVIC_SetPriority(SysTick_IRQn, 15U);

}





void Print_All_Clock_Freq(void)

{

    stc_clock_freq_t stcClkFreq;

    int32_t i32Ret;

    

    /* 1. (u揯齉pe穬諷@b	g憳噑 */

    i32Ret = CLK_GetClockFreq(&stcClkFreq);

    

    /* 2. 纇錱/f&T(ub烺 */

    if (i32Ret != LL_OK) {

        CLOCK_DEBUG("CLK_GetClockFreq failed! Error code: %d", i32Ret);

        return;

    }

    

    /* 3. SbpS@b	g鰁煍憳噑 */

    CLOCK_OUT("========== System Clock Frequencies ==========");

    CLOCK_OUT("System Clock (SYSCLK) : %u Hz", stcClkFreq.u32SysclkFreq);

    CLOCK_OUT("HCLK (AHB Clock)      : %u Hz", stcClkFreq.u32HclkFreq);

    CLOCK_OUT("PCLK0 (APB0 Clock)    : %u Hz", stcClkFreq.u32Pclk0Freq);

    CLOCK_OUT("PCLK1 (APB1 Clock)    : %u Hz", stcClkFreq.u32Pclk1Freq);

    CLOCK_OUT("PCLK2 (APB2 Clock)    : %u Hz", stcClkFreq.u32Pclk2Freq);

    CLOCK_OUT("PCLK3 (APB3 Clock)    : %u Hz", stcClkFreq.u32Pclk3Freq);

    CLOCK_OUT("PCLK4 (APB4 Clock)    : %u Hz", stcClkFreq.u32Pclk4Freq);

    CLOCK_OUT("External Clock (EXCLK): %u Hz", stcClkFreq.u32ExclkFreq);

    CLOCK_OUT("==============================================");

    

    /* 颯	俌済梺夢f鎷苸剉屨嬦Oo`颯錘(uCLOCK_DEBUGSbpS */

    CLOCK_DEBUG("Clock frequency acquisition completed successfully");

}

/*******************************************************************************

 * EOF

 ******************************************************************************/

